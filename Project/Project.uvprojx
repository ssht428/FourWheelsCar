# Keil uVision project Project.uvprojx, settings and files
target STM32F429xx (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429xx +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,
  c misc: --C99
  c include: ..\Library\CMSIS\Inc;..\Library\inc;..\User\inc;..\Library\STM32F429I-Discovery;..\Library\ModbusMaster;..\Library\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group CMSIS
    ../Library/CMSIS/Src/: system_stm32f4xx.c
  group Doc
    ../User/: readme.txt ProjectCreateSteps.txt
  group MDK-ARM
    ../Library/CMSIS/Src/: startup_stm32f429_439xx.s
  group STM32F4xx_StdPeriph_Driver
    ../Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hal.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../User/src/: main.c stm32f4xx_it.c ps2_spi.c mbcrc.c
  group STM32429-DISC
    ../Library/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_sdram.c stm32f429i_discovery_lcd.c stm32f429i_discovery_ioe.c
